# IAR project CDC_ACM.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: GD32F303xC GD GD32F303xC
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; GD32F30X_HD
  ICCARM.CCIncludePath2: ..\..\..\..\Firmware\CMSIS\GD\GD32F30x\Include; ..\..\..\..\Firmware\GD32F30x_standard_peripheral\Include; ..\..\..\..\Firmware\GD32F30x_usbd_driver\Include; ..\inc; ..\..\..\..\Utilities
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: CDC_ACM.srec
  ILINK.IlinkOutputFile: CDC_ACM.hex
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Appliction
    ../src/: cdc_acm0_core.c cdc_acm1_core.c dual_cdc_acm_core.c gd32f30x_it.c main.c
  group CMSIS
    ../../../../Firmware/CMSIS/GD/GD32F30x/Source/: system_gd32f30x.c
  group Doc
    ../: readme.txt
  group GD32F30x_EVAL
    ../../../../Utilities/: gd32f303e_eval.c
  group GD32F30x_Peripherals
    ../../../../Firmware/GD32F30x_standard_peripheral/Source/: gd32f30x_exmc.c gd32f30x_exti.c gd32f30x_fmc.c gd32f30x_gpio.c gd32f30x_misc.c gd32f30x_pmu.c gd32f30x_rcu.c gd32f30x_timer.c gd32f30x_usart.c
  group Startup
    ../../../../Firmware/CMSIS/GD/GD32F30x/Source/IAR/: startup_gd32f30x_hd.s
  group USB_Driver
    ../../../../Firmware/GD32F30x_usbd_driver/Source/: usbd_core.c usbd_int.c usbd_pwr.c usbd_std.c
